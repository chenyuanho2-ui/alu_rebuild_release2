# Keil uVision project alu_rebuild.uvprojx, settings and files
target alu_rebuild (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: alu_rebuild
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Aluminium/Inc;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include;../miku666;../miku666/pid
  asm include: ../Core/Inc
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: alu_main.c main.c gpio.c freertos.c crc.c dma2d.c fmc.c ltdc.c mdma.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group gui
    ../touchgfx/gui/src/containers/: filenamecnt.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/scrlaunch_screen/: scrlaunchpresenter.cpp scrlaunchview.cpp
    ../touchgfx/gui/src/scrmain_screen/: scrmainpresenter.cpp scrmainview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_adobeheitistd_regular_otf_30_4bpp_0.cpp font_adobeheitistd_regular_otf_30_4bpp_10.cpp font_adobeheitistd_regular_otf_30_4bpp_11.cpp font_adobeheitistd_regular_otf_30_4bpp_12.cpp font_adobeheitistd_regular_otf_30_4bpp_13.cpp font_adobeheitistd_regular_otf_30_4bpp_14.cpp font_adobeheitistd_regular_otf_30_4bpp_17.cpp font_adobeheitistd_regular_otf_30_4bpp_18.cpp font_adobeheitistd_regular_otf_30_4bpp_31.cpp font_adobeheitistd_regular_otf_30_4bpp_4.cpp font_adobeheitistd_regular_otf_30_4bpp_9.cpp font_adobeheitistd_regular_otf_40_4bpp_0.cpp font_adobeheitistd_regular_otf_40_4bpp_10.cpp font_adobeheitistd_regular_otf_40_4bpp_14.cpp font_adobeheitistd_regular_otf_40_4bpp_18.cpp font_adobeheitistd_regular_otf_40_4bpp_31.cpp font_adobeheitistd_regular_otf_40_4bpp_4.cpp font_times_10_4bpp_0.cpp font_times_10_4bpp_4.cpp font_verdana_20_4bpp_0.cpp font_verdana_40_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_adobeheitistd_regular_otf_30_4bpp.cpp kerning_adobeheitistd_regular_otf_40_4bpp.cpp kerning_times_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_40_4bpp.cpp table_adobeheitistd_regular_otf_30_4bpp.cpp table_adobeheitistd_regular_otf_40_4bpp.cpp table_times_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_40_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_cache.cpp image_del_blue.cpp image_del_white.cpp image_del_yellow.cpp image_file_open_blue.cpp image_file_open_yellow.cpp image_ico_add.cpp image_ico_add_activate.cpp image_ico_dev.cpp image_ico_dev_activate.cpp image_ico_file.cpp image_ico_file_activate.cpp
    ../touchgfx/generated/gui_generated/src/containers/: filenamecntbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/images/src/__designer/: image_blue_buttons_round_edge_small.cpp image_blue_buttons_round_edge_small_pressed.cpp image_blue_togglebars_toggle_round_large_button_off.cpp image_blue_togglebars_toggle_round_large_button_on.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/scrlaunch_screen/: scrlaunchviewbase.cpp
    ../touchgfx/generated/gui_generated/src/scrmain_screen/: scrmainviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Aluminium
    ../Aluminium/Src/: alu_control.c alu_file.c alu_temp.c touch_800x480.c touch_iic.c
  group miku666
    ../miku666/: ads1118.c temp_filter.c thermocouple.c task_control.c ui_task.c
  group pid
    ../miku666/pid/: advanced_pid.c fuzzy_pid.c pid.c pid_storage.c
software components: CMSIS:CORE 4.3.0
